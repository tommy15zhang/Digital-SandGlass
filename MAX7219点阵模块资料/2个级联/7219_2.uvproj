# Keil uVision project 7219_2.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(24000000)
  output: 7219_2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    D:/电子模块/点阵及数码管驱动模块/MAX7219点阵资料/2个级联/: STARTUP.A51
    ./: main.c
